# Keil uVision project Kv100_Return.uvproj, settings and files
target Kv100_Return (MCS-51)
  device: SC92F7251 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x0FFF) CLOCK(24000000)
  output: Kv100_Return +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group Startup
    ./startup/: STARTUP.A51
  group code
    ./code/: Adc.c iap.c initialSystem.c SystemSleep.c timer.c Uart.c returnMain.c
  group include
    ./include/: Adc.h all.h iap.h initialSystem.h SC92F725x_C.H SystemSleep.h timer.h Uart.h
